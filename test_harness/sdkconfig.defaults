## test_harness/sdkconfig.defaults
```kconfig
CONFIG_ESP_WIFI_ENABLED=y
CONFIG_ESP_WIFI_SOFTAP_SUPPORT=n
CONFIG_MDNS_ENABLED=y
CONFIG_HTTPD_WS_SUPPORT=y
CONFIG_ESP_TASK_WDT_TIMEOUT_S=10
```
